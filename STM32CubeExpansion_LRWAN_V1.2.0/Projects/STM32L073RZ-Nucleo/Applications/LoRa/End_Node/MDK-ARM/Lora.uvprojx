# Keil uVision project Lora.uvprojx, settings and files
target sx1276mb1mas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L053xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, REGION_EU868
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\Drivers\BSP\sx1276mb1mas
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/sx1272/: sx1272.c
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../../../../../Drivers/BSP/Components/sx126x/: radio.c sx126x.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../Drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
  group Drivers/BSP/sx1261dvk1bas
    ../../../../../../Drivers/BSP/SX1261DVK1BAS/: sx1261dvk1bas.c
  group Drivers/BSP/sx1262dvk1das
    ../../../../../../Drivers/BSP/SX1262DVK1DAS/: sx1262dvk1das.c
  group Drivers/BSP/sx1262dvk1cas
    ../../../../../../Drivers/BSP/SX1262DVK1CAS/: sx1262dvk1cas.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c
  group Projects/MDK-ARM
    ./: startup_stm32l073xx.s
  group Projects/End_Node
    ../LoRaWAN/App/src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c
    ../Core/src/: stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c
  group Middlewares/LoRaWAN/Core
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Core/: lora.c lora-test.c
  group Middlewares/LoRaWAN/Mac
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c LoRaMacAdr.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionRU864.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c queue.c trace.c systime.c
  group Middlewares/LoRaWAN/Crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
target sx1272mb2das (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L071xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,REGION_IN865
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx126x;..\..\..\..\..\..\Drivers\BSP\sx1262dvk1cas
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target sx1276mb1las (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\Drivers\BSP\sx1276mb1las
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target sx1261dvk1bas (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, REGION_EU868,USE_SX126X_DVK
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\Drivers\BSP\sx1276mb1las;..\..\..\..\..\..\Drivers\BSP\SX1261DVK1BAS;..\..\..\..\..\..\Drivers\BSP\Components\sx126x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target sx1262dvk1cas (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, REGION_IN865,USE_SX126X_DVK
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target sx1262dvk1das (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
